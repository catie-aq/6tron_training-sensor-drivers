## drivers/Kconfig
```kconfig
# Copyright (c) 2025 CATIE
# SPDX-License-Identifier: Apache-2.0

menu "Device Drivers"

rsource "sensor/Kconfig"

endmenu
```
